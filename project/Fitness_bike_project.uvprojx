# Keil uVision project Fitness_bike_project.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fitness_bike_project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\Lib\inc;..\User\main;..\CMSIS;..\User\rtt;..\User\resistance_level_driven;..\User\motor_driven;..\User\delay;..\User\key;..\User\uart;..\User\protocol
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group USER
    ../User/main/: main.c stm32l1xx_it.c
    ../User/motor_driven/: motor_driver.c
    ../User/delay/: delay.c
    ../User/resistance_level_driven/: resistance_level_driver.c
    ../User/key/: key.c
    ../User/uart/: uart.c uartdriver.c
    ../User/protocol/: protocol.c
  group CMSIS
    ../CMSIS/: system_stm32l1xx.c
  group LIB
    ../Lib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group STARTUP
    ../StartUp/: startup_stm32l1xx_md.s
